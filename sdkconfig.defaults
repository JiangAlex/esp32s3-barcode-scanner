## sdkconfig.defaults
```kconfig
CONFIG_PM_ENABLE=n
CONFIG_FREERTOS_HZ=100
CONFIG_ESPTOOLPY_FLASH_SAMPLE_MODE_STR=y
```
